FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SPLASH_IMAGES_rpi = "file://psplash-arig-img.h;outsuffix=arig"
