FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"

SYSTEMD_AUTO_ENABLE = "enable"